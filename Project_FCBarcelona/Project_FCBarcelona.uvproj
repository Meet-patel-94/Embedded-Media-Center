# Keil uVision project Project_FCBarcelona.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project_FCBarcelona
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c cmsis_os.h LPC17xx.h
  group Source Code
    ./: Project_FCBarcelona.c IRQ.c GLCD_SPI_LPC1700.c LED.c KBD.c ADC.h KBD.h GLCD.h
  group Pictures
    ./: image0.c image1.c image2.c image3.c
  group Game Pictures
    ./: NEON_BLUE.c NEON_RED.c NEON_YELLOW.c YELLOW_BLOCK.c BLUE_BLOCK.c RED_BLOCK.c GREEN_BLOCK.c BLOCK_WHITE.c BACK_GREY1.c BACK.c BACK_GREY.c tetrislogo.c NEON_GREEN.c
  group USB
    ./: adcuser.c usbdmain.c usbuser.c usbcore.c usbdesc.c usbhw.c
